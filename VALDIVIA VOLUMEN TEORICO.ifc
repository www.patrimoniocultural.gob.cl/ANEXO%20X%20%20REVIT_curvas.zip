Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-08-12T12:41:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 12 12:41:16 2021 * Host: TL_09_DC * Database: C:\Users\David\AppData\Local\Temp\{0955895D-8E3C-478C-A959-E83E3966223A}\ifc * Database version: 5507 * Database creation date: Thu Aug 12 12:41:15 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 12 12:41:15 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 12 12:41:15 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
