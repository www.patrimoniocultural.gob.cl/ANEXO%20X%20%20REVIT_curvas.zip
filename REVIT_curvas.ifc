Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-12T10:39:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180328_1600(x64) - Exporter 19.0.1.1 - IU alternativa 19.0.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 12 10:39:14 2021 * Host: DESKTOP-MBN0IO2 * Database: C:\Users\Usuario\AppData\Local\Temp\{26065459-05C3-4131-8FD5-02A382BF71CE}\ifc * Database version: 5507 * Database creation date: Thu Aug 12 10:39:14 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 12 10:39:14 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 12 10:39:14 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
